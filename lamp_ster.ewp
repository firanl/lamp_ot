# IAR project lamp_ster.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW30Z160xxx4 Freescale MKW30Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW30Z160VHM4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: lamp/bluetooth/otap_client_att/app_preinclude.h
  ICCARM.CCIncludePath2: platform/CMSIS/Include; boards/lamp30z_hw1; lamp/bluetooth/addons/tpm_pwm_led; lamp/bluetooth/addons/temperature_sensor; platform/devices; platform/devices/MKW30Z4/include; platform/devices/MKW30Z4/startup; platform/system/src/clock/MKW30Z4; platform/devices; platform/devices/MKW30Z4/startup; framework/Flash/External/Interface; framework/Flash/Internal; platform/drivers/src/flash/C90TFS/drvsrc/include; framework/GPIOIrq; framework/Keyboard/Interface; framework/LED/Interface; framework/SerialManager/Source/SPI_Adapter; framework/Common; framework/MemManager/Interface; framework/Messaging/Interface; framework/LowPower/Interface/MKW4xZ; framework/LowPower/Interface/MKW4xZ; framework/OSAbstraction/Interface; platform/osa/inc; framework/OtaSupport/Interface; framework/Panic/Interface; framework/RNG/Interface; framework/SerialManager/Interface; framework/TimersManager/Interface; framework/TimersManager/Source; framework/FunctionLib; framework/Lists; framework/SecLib; framework/ModuleInfo; bluetooth/host/interface; lamp/bluetooth/common; lamp/bluetooth/common; bluetooth/controller/interface; lamp/bluetooth/common; bluetooth/hci_transport/interface; lamp/bluetooth/common/gatt_db; lamp/bluetooth/common/gatt_db/macros; bluetooth/profiles/battery; bluetooth/profiles/device_info; bluetooth/profiles/otap; bluetooth/profiles/lamp_basic; framework/XCVR/MKW30Z4; lamp/bluetooth/otap_client_att/common; framework/DCDC/Interface; platform/drivers/inc; platform/system/inc; platform/hal/inc; platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: otap_client_att_BM.srec
  ILINK.IlinkOutputFile: otap_client_att_BM.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; gUseBootloaderLink_d=0; gUseInternalStorageLink_d=0; __ram_vector_table__=1
  ILINK.IlinkIcfFile: platform/devices/MKW30Z4/linker/iar/MKW30Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: bluetooth/host/lib/ble_host_peripheral_lib.a; lib/ksdk_platform_lib/iar/KW30Z4/debug/libksdk_platform.a; framework/SecLib/lib_crypto_IAR_M0.a; bluetooth/controller/lib/ble_controller_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW30Z160VHM4
  ICCARM.CCIncludePath2: platform/CMSIS/Include; boards/lamp30z_hw1; lamp/bluetooth/addons/tpm_pwm_led; platform/devices; platform/devices/MKW30Z4/include; platform/devices/MKW30Z4/startup; platform/system/src/clock/MKW30Z4; platform/devices; platform/devices/MKW30Z4/startup; framework/Flash/External/Interface; framework/Flash/Internal; platform/drivers/src/flash/C90TFS/drvsrc/include; framework/GPIOIrq; framework/Keyboard/Interface; framework/LED/Interface; framework/SerialManager/Source/SPI_Adapter; framework/Common; framework/MemManager/Interface; framework/Messaging/Interface; framework/LowPower/Interface/MKW4xZ; framework/LowPower/Interface/MKW4xZ; framework/OSAbstraction/Interface; platform/osa/inc; framework/OtaSupport/Interface; framework/Panic/Interface; framework/RNG/Interface; framework/SerialManager/Interface; framework/TimersManager/Interface; framework/TimersManager/Source; framework/FunctionLib; framework/Lists; framework/SecLib; framework/ModuleInfo; bluetooth/host/interface; lamp/bluetooth/common; lamp/bluetooth/common; bluetooth/controller/interface; lamp/bluetooth/common; bluetooth/hci_transport/interface; lamp/bluetooth/common/gatt_db; lamp/bluetooth/common/gatt_db/macros; bluetooth/profiles/battery; bluetooth/profiles/device_info; bluetooth/profiles/otap; framework/XCVR/MKW30Z4; lamp/bluetooth/otap_client_att/common; framework/DCDC/Interface; platform/drivers/inc; platform/system/inc; platform/hal/inc; platform/utilities/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_platform_lib\iar\KW40Z4\release\libksdk_platform.a; framework/SecLib/lib_crypto_IAR_M0.a; bluetooth/controller/lib/ble_controller_lib.a
  group app/common
    lamp/bluetooth/common/: ApplMain.c ApplMain.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h
  group app/common/gatt_db
    lamp/bluetooth/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group app/common/gatt_db/macros
    lamp/bluetooth/common/gatt_db/macros/: gatt_alloc_x.def gatt_db_macros.h gatt_db_x_macros.def gatt_decl_x.def gatt_enum_x.def gatt_init_x.def gatt_size_x.def gatt_uuid_decl_x.def gatt_uuid_def_x.def
  group app/otap_client_att
    lamp/bluetooth/otap_client_att/common/: app.c app.h app_config.c gatt_db.h gatt_uuid128.h
    lamp/bluetooth/otap_client_att/: app_preinclude.h
  group bluetooth/controller/interface
    bluetooth/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    bluetooth/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    bluetooth/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/interface
    bluetooth/host/interface/: att_errors.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h smp_packets.h smp_types.h vendor_debug_commands.h
  group bluetooth/host/source
    bluetooth/host/source/: ble_globals.c
  group bluetooth/profiles/battery
    bluetooth/profiles/battery/: battery_service.c
  group bluetooth/profiles/device_info
    bluetooth/profiles/device_info/: device_info_service.c
  group bluetooth/profiles/interface
    bluetooth/profiles/battery/: battery_interface.h
    bluetooth/profiles/device_info/: device_info_interface.h
    bluetooth/profiles/lamp_basic/: lamp_interface.h
    bluetooth/profiles/otap/: otap_interface.h
  group bluetooth/profiles/lamp_basic
    bluetooth/profiles/lamp_basic/: lamp_service.c
  group bluetooth/profiles/otap
    bluetooth/profiles/otap/: otap_service.c
  group framework/Common
    framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/DCDC/Interface
    framework/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    framework/DCDC/Source/: DCDC.c
  group framework/Flash/External/Interface
    framework/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    framework/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/Flash/Internal
    ../../KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
    ../../KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group framework/FunctionLib
    framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    framework/LED/Interface/: LED.h
  group framework/LED/Source
    framework/LED/Source/: LED.c
  group framework/Lists
    framework/Lists/: GenericList.c GenericList.h
  group framework/LowPower/Interface
    framework/LowPower/Interface/MKW4xZ/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    framework/LowPower/Source/MKW4xZ/: PWR.c PWR_BLE.c PWR_BLE.h PWRLib.c PWRLib.h
  group framework/MemManager/Interface
    framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    framework/OSAbstraction/Source/: fsl_osa_ext_bm.c
  group framework/OtaSupport/Interface
    framework/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    framework/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    framework/Reset/: Reset.c
  group framework/RNG/Interface
    framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    framework/RNG/Source/: RNG.c
  group framework/SecLib
    framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/TimersManager/Interface
    framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW30Z4
    framework/XCVR/MKW30Z4/: BLEDefaults.h ifr_mkw30z4_radio.c ifr_mkw30z4_radio.h ifr_tbl_mkw30z4_radio.h KW3xXcvrDrv.c KW3xXcvrDrv.h overwrites.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group KSDK
    boards/lamp30z_hw1/: board.c board.h gpio_pins.h
    lamp/bluetooth/addons/temperature_sensor/: temperature_sensor.c temperature_sensor.h
    lamp/bluetooth/addons/tpm_pwm_led/: tpm_pwm_led_ctrl.c tpm_pwm_led_ctrl.h
  group RTOS/Startup
    platform/devices/: startup.c startup.h
    platform/devices/MKW30Z4/startup/iar/: startup_MKW30Z4.s
    platform/devices/MKW30Z4/startup/: system_MKW30Z4.c system_MKW30Z4.h
